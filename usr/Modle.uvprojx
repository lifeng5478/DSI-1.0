# Keil uVision project Modle.uvprojx, settings and files
target Modle (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Modle +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,
  c include: ..\lib\inc;..\usr;..\CM4;..\lib\CMSIS\Device\ST\STM32F4xx\Include;..\uCOS-III-Source\Source;..\uC-LIB;..\uC-CPU\ARM-Cortex-M4\RealView;..\BSP;..\APP;..\uC-CPU;..\uCOS-III-Ports\Ports\ARM-Cortex-M4\Generic\RealView;..\emWin\Config;..\emWin\inc;..\emWin\OS;..\BSP\lcd;..\BSP\sdram;..\BSP\TouchPad;..\BSP\touch;..\BSP\usart;..\BSP\sim900a;..\PNGLib;..\BSP\E2PROM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Usr
    ./: stm32f4xx_conf.h main.c speedtest.c stm32f4xx_it.c Test1.c
    ../BSP/usart/: bsp_usart2.c bsp_debug_usart.c
  group APP
    ../APP/: app.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group BSP
    ../BSP/: bsp.c LED.c bsp_int.c FAN.c encoder.c
    ../BSP/lcd/: bsp_lcd.c
    ../BSP/sdram/: bsp_sdram.c
    ../BSP/TouchPad/: bsp_touchpad.c
    ../BSP/touch/: bsp_i2c_touch.c gt9xx.c
    ../BSP/sim900a/: sim900a.c
    ../BSP/E2PROM/: I2C_E2PROM.c
  group uC-CPU
    ../uC-CPU/: cpu_core.c cpu_def.h
    ../uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group CM4
    ../CM4/: system_stm32f4xx.c stm32f4xx.h
  group Startups
    ../starups/: startup_stm32f429_439xx.s
  group Lib
    ../lib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_fmc.c stm32f4xx_ltdc.c stm32f4xx_tim.c stm32f4xx_dma2d.c stm32f4xx_i2c.c stm32f4xx_usart.c
  group uC-LIB
    ../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uCOS-III-Ports
    ../uCOS-III-Ports/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uCOS-III-Source
    ../uCOS-III-Source/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group StemwinConfig
    ../emWin/Config/: GUIConf.c GUIConf.h GUIDRV_wf.c LCDConf.h
    ../emWin/OS/: GUI_X_uCOS.c
  group StemwinLib
    ../emWin/Lib/: STemWin528_CM4_Keil.lib
  group PNGLib
    ../PNGLib/: adler32.c compress.c crc32.c deflate.c GUI_PNG.c gzio.c IMAGE_PNG.c infback.c inffast.c inflate.c inftrees.c png.c pngerror.c pnggccrd.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngvcrd.c pngwio.c pngwrite.c pngwtran.c pngwutil.c trees.c uncompr.c zutil.c
  group image
    ./: header.c
    ../image/: BT1.c BT2.c blueBT1.c blueBT2.c off.c ON.c BT3.c OK.c cancle.c
  group Fonts
    ../Fonts/: song40.c number.c xuanxiang24.c CommercialScript BT20.c SWScrpc60.c
  group readme
    ../BSP/: GPIOX.txt
